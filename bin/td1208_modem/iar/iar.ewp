# IAR project iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32TG210F32 EnergyMicro EFM32TG210F32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32TG210F32; DEBUG_EFM
  ICCARM.CCIncludePath2: ..\..\CMSIS\CM3\CoreSupport; ..\..\CMSIS\CM3\DeviceSupport\EnergyMicro\EFM32; ..\..\efm32lib\inc; ..\inc; ..\..\libtd1202\inc; ..\..\..\drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\CMSIS\CM3\CoreSupport; ..\..\..\..\..\CMSIS\CM3\DeviceSupport\EnergyMicro\EFM32; ..\..\..\..\..\efm32lib\inc; ..\..\..\drivers
  OBJCOPY.OOCOutputFile: iar.bin
  ILINK.IlinkOutputFile: iar.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\EnergyMicro\EFM32TG210F32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32TG210F32
  group CMSIS
    ../../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../CMSIS/CM3/DeviceSupport/EnergyMicro/EFM32/startup/iar/: startup_efm32tg.c
    ../../CMSIS/CM3/DeviceSupport/EnergyMicro/EFM32/: system_efm32.c
  group efm32lib
    ../../efm32lib/src/: efm32_acmp.c efm32_adc.c efm32_aes.c efm32_assert.c efm32_burtc.c efm32_cmu.c efm32_dac.c efm32_dbg.c efm32_dma.c efm32_ebi.c efm32_emu.c efm32_gpio.c efm32_i2c.c efm32_int.c efm32_lcd.c efm32_lesense.c efm32_letimer.c efm32_leuart.c efm32_mpu.c efm32_msc.c efm32_opamp.c efm32_pcnt.c efm32_prs.c efm32_rmu.c efm32_rtc.c efm32_system.c efm32_timer.c efm32_usart.c efm32_vcmp.c efm32_wdog.c
  group LibTD1202
    ../../libtd1202/src/: td_cmu.c td_flash.c td_gpio.c td_loader.c td_measure.c td_printf.c td_rf.c td_rf_Si4461.c td_rtc.c td_sigfox.c td_spi.c td_timer.c td_uart.c td_utils.c
  group Source
    ../src/: at_advanced_mode.c at_cert_test.c at_connected_mode.c at_local.c at_mfg_test.c at_parse.c at_radio.c at_sigfox.c gpio_test.c main.c rf_cem_test.c rf_cert_test.c rf_local.c rf_mfg_test.c
