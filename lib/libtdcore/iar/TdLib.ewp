# IAR project TdLib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32TG210F32 EnergyMicro EFM32TG210F32
  ICCARM.CCDefines: EFM32TG210F32; DEBUG_EFM; DEBUG
  ICCARM.CCIncludePath2: ..\..\CMSIS\CM3\CoreSupport; ..\..\CMSIS\CM3\DeviceSupport\EnergyMicro\EFM32; ..\..\efm32lib\inc; ..\..\libtd1202\inc; ..\include; ..\..\drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: TdLib.out
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; EFM32TG210F32
  ICCARM.CCIncludePath2: ..\..\libtd1202\inc; ..\include; ..\..\drivers; ..\..\CMSIS\CM3\CoreSupport; ..\..\CMSIS\CM3\DeviceSupport\EnergyMicro\EFM32; ..\..\efm32lib\inc
  group (top)
    ../src/: td_cmu.c td_flash.c td_gpio.c td_loader.c td_measure.c td_printf.c td_rf.c td_rf_Si4461.c td_rtc.c td_sigfox.c td_spi.c td_timer.c td_uart.c
